# IAR project ColomoBLE.ewp, settings and files
configuration CC2541 (8051, debug)
  General.OGChipSelectMenu: CC2541F256 CC2541F256
  ICC8051.CCDefines: INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; xHAL_AES_DMA; xHAL_DMA; POWER_SAVING; xPLUS_BROADCASTER; HAL_LED; BLINK_LEDS; HAL_I2C=TRUE; CC2541; DBG_UART=TRUE; xDBG_SLEEP=TRUE; xDISCOVERABLE_LIMITED; xDISCOVERABLE_INIT; xBLEDEBUG; xAC_BEEP; HAL_ADC=TRUE; HAL_DMA=TRUE; HAL_TIME=TRUE; WECHAT=TRUE
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\common; ..\..\include; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2541CLM; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\phy; ..\..\..\..\Components\ble\controller\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\common\cc2541; ..\..\common\npi\npi_np; ..\..\Profiles\Roles; ..\..\Profiles\ColomoProfile; ..\..\Profiles\DevInfo; ..\..\Profiles\WeChatProfile; ..\wechat
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: ..\..\common\cc2540\ti_51ew_cc2540b.xcl
configuration CC2541-OAD-ImgA-Sun (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; xHAL_AES_DMA; xHAL_DMA; POWER_SAVING; xPLUS_BROADCASTER; HAL_LED; BLINK_LEDS; HAL_I2C=TRUE; CC2541; xDBG_UART=TRUE; xDBG_SLEEP=TRUE; xDISCOVERABLE_LIMITED; xDISCOVERABLE_INIT; xBLEDEBUG; xAC_BEEP; HAL_ADC=TRUE; HAL_DMA=TRUE; FEATURE_OAD; OAD_KEEP_NV_PAGES; FEATURE_OAD_BIM; HAL_IMAGE_A; xCATCH_LOG; xWECHAT=TRUE
  ICC8051.CCIncludePath2: ..\..\common; ..\..\include; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2541CLM; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\phy; ..\..\..\..\Components\ble\controller\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\common\cc2541; ..\..\common\npi\npi_np; ..\..\Profiles\Roles; ..\..\Profiles\ColomoProfile; ..\..\Profiles\DevInfo; ..\..\Profiles\OAD; ..\..\Profiles\WeChatProfile; ..\Wechat
  postbuild: "..\..\common\CC2540\cc254x_ubl_pp.bat" "$PROJ_DIR$" "ProdUBL" "CC2541-OAD-ImgA-Sun\Exe\ColomoBLE"
  XLINK.XclFile: ..\..\common\CC2541\cc254x_f256_imgA.xcl
configuration CC2541-OAD-ImgB-Sun (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; xHAL_AES_DMA; xHAL_DMA; POWER_SAVING; xPLUS_BROADCASTER; HAL_LED; BLINK_LEDS; HAL_I2C=TRUE; CC2541; xDBG_UART=TRUE; xDBG_SLEEP=TRUE; xDISCOVERABLE_LIMITED; xDISCOVERABLE_INIT; xBLEDEBUG; xAC_BEEP; HAL_ADC=TRUE; HAL_DMA=TRUE; FEATURE_OAD; OAD_KEEP_NV_PAGES; FEATURE_OAD_BIM; HAL_IMAGE_B; WECHAT=TRUE
  ICC8051.CCIncludePath2: as above
  postbuild: "..\..\common\CC2540\cc254x_ubl_pp.bat" "$PROJ_DIR$" "ProdUBL" "CC2541-OAD-ImgB-Sun\Exe\ColomoBLE"
  XLINK.XclFile: ..\..\common\CC2541\cc254x_f256_imgB.xcl
  group APP
    ../Source/: ColomoBLE.c ColomoBLE.h ColomoBLE_Main.c OSAL_ColomoBLE.c WeChat.c WeChat.h
  group HAL/Common
    ../../../../Components/hal/target/CC2541CLM/: hal_drivers.c
  group HAL/Include
    ../../../../Components/hal/include/: hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_rpc.h hal_sleep.h hal_timer.h hal_uart.h
    ../../../../Components/services/saddr/: saddr.h
  group HAL/Target/CC2541CLM/Config
    ../../../../Components/hal/target/CC2541CLM/: hal_board_cfg.h
  group HAL/Target/CC2541CLM/Drivers
    ../../../../Components/hal/target/CC2541CLM/: bsp_acc.c bsp_cap_io.c bsp_color_9300.c bsp_isr.c bsp_ruby_flash.c bsp_ruby_led.c bsp_ruby_lum.c bsp_ruby_motor.c bsp_ruby_res.c bsp_ruby_timer.c bsp_smart_cover.c bsp_uart.c hal_adc.c hal_crc.c hal_dma.c hal_flash.c hal_i2c.c hal_sleep.c hal_startup.c
    ../../Profiles/DevInfo/: devinfoservice.c
  group HAL/Target/CC2541CLM/Includes
    ../../../../Components/hal/target/CC2541CLM/: hal_mcu.h hal_types.h
  group INCLUDE
    ../../../../Components/ble/include/: att.h gap.h gatt.h gatt_uuid.h hci.h l2cap.h sm.h
    ../../../../Components/ble/host/: linkdb.h
    ../../../../Components/ble/controller/include/: ll.h phy.h
    ../../common/npi/npi_np/: npi.h
  group LIB
    ../../Libraries/CC2541DB/bin/: CC2541_BLE_peri.lib
    ../../Libraries/Common/bin/: CC254x_BLE_HCI_TL_None.lib
  group NPI
    ../../common/npi/npi_np/: npi.c
  group OSAL
    ../../../../Components/ble/include/: bcomdef.h
    ../../../../Components/osal/common/: OSAL.c osal_bufmgr.c osal_cbtimer.c OSAL_ClockBLE.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../../Components/osal/mcu/cc2540/: osal_snv.c
  group PROFILES
    ../../Profiles/ColomoProfile/: ColomoService.c ColomoService.h
    ../../Profiles/DevInfo/: devinfoservice.h
    ../../Profiles/Roles/: gap.c gapbondmgr.c gapbondmgr.h peripheral.c peripheral.h
    ../../Include/: gapgattserver.h gattservapp.h
    ../../../../Components/ble/host/: gatt_uuid.c
    ../../Profiles/OAD/: oad.h oad_target.c oad_target.h
    ../../Profiles/WeChatProfile/: WeChatService.c wechatservice.h
  group TOOLS
    ../../config/: buildComponents.cfg
    ./: buildConfig.cfg
    ../../common/cc2541/: OnBoard.c OnBoard.h
  group WeChat
    ../Wechat/: ble_wechat_util.c ble_wechat_util.h epb.c epb.h epb_MmBp.c epb_MmBp.h
